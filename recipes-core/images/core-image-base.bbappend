
IMAGE_ROOTFS_SIZE = "16384"
IMAGE_INSTALL += "ssh openssh "
